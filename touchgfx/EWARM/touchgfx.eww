<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\touchgfx.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>everything</name>
            <member>
                <project>touchgfx</project>
                <configuration>TouchGFX-STM32H750B-DK_OoB</configuration>
            </member>
            <member>
                <project>touchgfx</project>
                <configuration>TouchGFX-STM32H750B-DK</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
